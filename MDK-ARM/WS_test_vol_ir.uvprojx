# Keil uVision project WS_test_vol_ir.uvprojx, settings and files
target WS_test_vol_ir (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: WS_test_vol_ir
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Drivers/CMSIS/Include;  ..\Src\Nec;  ..\Src\Init_main
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c event_groups.c queue.c croutine.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c main.c stm32f4xx_it.c freertos.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Nec
    ../Src/Nec/: Nec.h Nec.c
  group Init_main
    ../Src/Init_main/: init_main.c init_main.h
software components: CMSIS:CORE 4.1.0
